<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\heater.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\test1\test.ewp</path>
    </project>
    <batchBuild />
</workspace>
