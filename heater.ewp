# IAR project heater.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S903F3 STM8S903F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S903
  ICCSTM8.CCIncludePath2: inc; lib\SPL\inc; lib\ts\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: SPL_STM8S_template.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group inc
    inc/: proj_conf.h stm8_tsl_conf.h stm8s_conf.h stm8s_it.h
  group lib/SPL/inc
    lib/SPL/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group lib/SPL/src
    lib/SPL/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart4.c stm8s_wwdg.c
  group lib/ts/inc
    lib/ts/inc/: stm8_tsl_api.h stm8_tsl_checkconfig.h stm8_tsl_conf_RC_TOADAPT.h stm8_tsl_internal.h stm8_tsl_multichannelkey.h stm8_tsl_rc_acquisition.h stm8_tsl_services.h stm8_tsl_singlechannelkey.h stm8_tsl_timebase.h
  group lib/ts/src
    lib/ts/src/: stm8_tsl_api.c stm8_tsl_multichannelkey.c stm8_tsl_rc_acquisition.c stm8_tsl_services.c stm8_tsl_singlechannelkey.c stm8_tsl_timebase.c
  group src
    src/: main.c stm8s_it.c
